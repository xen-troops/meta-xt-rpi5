DEPENDS:append = "xen xen-tools"

IMAGE_BOOT_FILES:append = "xen-${MACHINE};Image"
