DESCRIPTION = "A small image just capable of allowing a device to boot and \
is suitable for development work."

require rpi-image-minimal.bb
require include/rpi-image-dev.inc
