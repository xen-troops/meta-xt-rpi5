UBOOT_MACHINE = "rpi_arm64_config"

COMPATIBLE_MACHINE:raspberrypi5 = "raspberrypi5"
